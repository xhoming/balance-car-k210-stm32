# Keil uVision project my_balance.uvprojx, settings and files
target my_balance (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: my_balance +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../BSP;../BSP/Battery;../BSP/Beep;../BSP/Bluetooth;../BSP/delay;../BSP/Enconder;../BSP/IIC_Software;../BSP/INT_Sever;../BSP/k210;../BSP/Key;../BSP/LED;../BSP/Motor;../BSP/MPU6050;../BSP/MPU6050/DMP;../BSP/OLED;../BSP/Timer;../BSP/Usart1;../APP;../APP/filter;../APP/KF;../APP/mode;../APP/OLED_Show;../APP/PID
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group BSP
    ../BSP/: AllHeader.h myenum.h bsp.c
    ../BSP/Battery/: bsp_battery.c
    ../BSP/Beep/: bsp_beep.c
    ../BSP/Bluetooth/: bsp_bluetooth.c app_bluetooth.c
    ../BSP/delay/: delay.c
    ../BSP/Enconder/: encoder.c
    ../BSP/IIC_Software/: IOI2C.c
    ../BSP/INT_Sever/: intsever.c
    ../BSP/k210/: bsp_usart2.c
    ../BSP/Key/: bsp_key.c
    ../BSP/LED/: bsp_LED.c
    ../BSP/Motor/: motor.c
    ../BSP/MPU6050/: mpu6050.c
    ../BSP/OLED/: oled_fonts.c bsp_oled_i2c.c bsp_oled.c
    ../BSP/Timer/: bsp_timer.c
    ../BSP/Usart1/: bsp_usart.c
  group APP
    ../APP/: app.c app_control.c app_motor.c app_user.c app_vision_turn.c app_ball_kick.c
    ../APP/OLED_Show/: oled_show.c
    ../APP/mode/: app_mode.c
  group DMP
    ../BSP/MPU6050/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group algorithm
    ../APP/filter/: filter.c
    ../APP/KF/: KF.c
    ../APP/PID/: pid_control.c
software components: CMSIS:CORE 4.3.0
